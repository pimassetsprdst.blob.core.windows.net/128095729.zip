Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-10-23T12:05:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 23 12:05:39 2018 * Host: B3ROBRAWR3853 * Database: C:\Users\LC\AppData\Local\Temp\{63D8C19A-E0E5-487F-BAE1-8C469AFF41B4}\ifc * Database version: 5507 * Database creation date: Tue Oct 23 12:05:39 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Oct 23 12:05:39 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 23 12:05:39 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcDistributionControlElement: SAF_A1.0.11-24, HC_Control Unit_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_HVAC-Control Element_DE-DE:SAF_A1.0.11-24:1451430
In: V00
Type - Material: Color RGB 110-110-110, Color RAL 9016
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Depth: 24 mm; Height: 80.5 mm; Width: 80.5 mm
Type - Identity Data - Article Type: SAF/A1.0.11-24; Base Family Version: 11.20; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: SAF/A1.0.11-24 HVAC-control element; EMCS Version: 4.0; ETIM Article Class: EC001101; Family Version: 11.18; Manufacturer: ABB; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA006134A0347,artikel.html; MEPcontent Class: CONTROL_UNIT_HC; Model: SAF/A1.0.11-24; OmniClass Number: 23.75.65.11.11; OmniClass Title: Heating Controllers; Revit Version: 2017; Type Name: SAF_A1.0.11-24; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Body: Color RAL 9016; Grey: Color RGB 110-110-110
Type - Other - Category: Mechanical Equipment; Family Name: HC_Control Unit_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_HVAC-Control Element_DE-DE
Type - Text - Article Description: SAF/A1.0.11-24 HVAC-control element; GTIN: 4011395252109; Manufacturer Art. No.: 2CKA006134A0347; Product Line: KNX-User Operation - ClimaEco Sensors
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Elevation: 0 mm
Dimensions - Area: 0.0178002 m2; Volume: 0.000108212 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Communication
Other - Family: HC_Control Unit_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_HVAC-Control Element_DE-DE: SAF_A1.0.11-24; Family and Type: HC_Control Unit_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_HVAC-Control Element_DE-DE: SAF_A1.0.11-24; Type: HC_Control Unit_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_HVAC-Control Element_DE-DE: SAF_A1.0.11-24; Type Id: HC_Control Unit_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_HVAC-Control Element_DE-DE: SAF_A1.0.11-24
Phasing - Phase Created: 3. Nieuwbouw
